# Keil uVision project Project.uvprojx, settings and files
target HY-LPC1788-SDK (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: LPC1788 NXP
  pack: Keil.LPC1700_DFP.2.2.0
  cpu: IROM(0x00000000,0x80000) IRAM(0x10000000,0x10000) IRAM2(0x20000000,0x8000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: project +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: ..\..\Common\lpc177x.lpc178x.cmsis.driver.library_2012.8.13\Core\Device\NXP\LPC177x_8x\Include;..\..\Common\lpc177x.lpc178x.cmsis.driver.library_2012.8.13\Core\CMSIS\Include;..\USER\TSC2046;..\..\Common\lpc177x.lpc178x.cmsis.driver.library_2012.8.13\Drivers\include;..\USER\GLCD;..\USER\SDRAM
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x10000
  memory RVCT10: RAM 0x20000000 size 0x8000
  group User
    ../USER/: main.c
  group GLCD
    ../USER/GLCD/: GLCD.c
    ../USER/TSC2046/: AsciiLib.c
  group SDRAM
    ../USER/SDRAM/: SDRAM_K4S561632C_128Mbit.c SDRAM_K4M563233G_256Mbit.c SDRAM_K4M563233G_32M_32BIT.c
  group TSC2046
    ../USER/TSC2046/: Calibrate.c TouchPanel.c
  group lpc177x.lpc178x.cmsis.driver.library_2012.8.13
    ../../Common/lpc177x.lpc178x.cmsis.driver.library_2012.8.13/Drivers/source/: lpc177x_8x_clkpwr.c lpc177x_8x_gpio.c lpc177x_8x_pinsel.c lpc177x_8x_ssp.c
  group CMSIS-CM3
    ../../Common/lpc177x.lpc178x.cmsis.driver.library_2012.8.13/Core/Device/NXP/LPC177x_8x/Source/Templates/: system_LPC177x_8x.c
  group Startup
    ../../Common/lpc177x.lpc178x.cmsis.driver.library_2012.8.13/Core/Device/NXP/LPC177x_8x/Source/Templates/ARM/: startup_LPC177x_8x.s
  group Doc
    ../: abstract.txt readme.txt
software components: CMSIS:CORE 4.3.0
